# Repository Seizeweb/extra-safety-valve-V1

File README.md:

# extra-safety-valve-V1

Upgraded version of LMNC's safety valve. 

Smaller, with CV inputs for tone and gain.

My idea is to have connecting point for vactrols at the CV inputs, the builder can decide what vactrol he puts in to have different responses (even a DIY vactrol). 

Everything is untested !

## EAGLE design eagle files/Safety Valve SMT.brd

Parts:
C1, C2, C6: 47nF; C0805
C3, C4: 100nF; C0805
C7: 10nF; C0805
GAIN: 9MM_SNAP-IN_POT_; 9MM_SNAP-IN_POT
GAIN_IN: THONKICONNNEW; WQP-PJ301M-12_JACK
IC1: TL072; SO08
IN: SOCKET_MONO_3.5MMPJ301M-12; PJ301M-12
LDR1, LDR2: VACTROL_4PIN; VACTROL_4PIN_VTL5C
OUT: SOCKET_MONO_3.5MMPJ301M-12; PJ301M-12
R1: 470R; M0805
R2, R13: value; R0805
R3: 1M; M0805
R4: 27; R0805
R5: 220k; M0805
R6: 220k; R0805
R7, R14: 10k; R0805
R8, R9: 470k; M0805
R10: 100k; R0805
R11: 100k; M0805
R12, R15: 39k; R0805
R16, R17: 470; M0805
T1, T2: BC807-16-PNP-SOT23-BEC; SOT23-BEC
TONE: 9MM_SNAP-IN_POT_; 9MM_SNAP-IN_POT
TONE_IN: THONKICONNNEW; WQP-PJ301M-12_JACK
U1, U2: TL072_SMD; SO08
V1: 12AX7
VOLUME: 100k; POTENTIOMETER_9MM

Connections:
+12V: C3.1, GAIN.3 (E), IC1.8 (V+), R5.2, R6.2, R16.1, R17.1, TONE.3 (E); also elsewhere on the board
-12V: C4.2, GAIN.1 (A), IC1.4 (V-), LDR1.1 (LED-), LDR2.1 (LED-), R4.1, TONE.1 (A); also elsewhere on the board
GND: C3.2, C4.1, GAIN_IN.P$3_SLEEVE (SLEEVE), IC1.3 (+IN), IC1.5 (+IN), IN.GND (SLEEVE), OUT.GND (SLEEVE), R8.2, R9.1, R12.2, R15.2, TONE_IN.P$3_SLEEVE (SLEEVE), V1.P$4 (H1), V1.P$8 (TK), VOLUME.P$1 (1); also elsewhere on the board
unnamed: R17.2, T2.E, U2.2 (-IN)
unnamed: IC1.2 (-IN), R1.2, R3.2
unnamed: C2.2, C7.1, VOLUME.P$3 (3)
unnamed: IC1.1 (OUT), OUT.TIP, R3.1
unnamed: C2.1, R6.1, V1.P$6 (TA)
unnamed: C6.1, R5.1, V1.P$1 (TA)
unnamed: C1.2, R9.2, V1.P$2 (TG)
unnamed: C1.1, IC1.7 (OUT), R11.1
unnamed: R4.2, V1.P$5 (H3)
unnamed: C6.2, R8.1, V1.P$7 (TG)
unnamed: IN.TIP, R10.2
unnamed: T2.B, U2.1 (OUT)
unnamed: IC1.6 (-IN), R10.1, R11.2
unnamed: R1.1, VOLUME.P$2 (2)
unnamed: LDR1.3 (RES1), V1.P$3 (TK)
unnamed: C7.2, LDR2.3 (RES1)
unnamed: R16.2, T1.E, U1.2 (-IN)
unnamed: T1.B, U1.1 (OUT)
unnamed: R2.1, R7.1, R12.1, U1.3 (+IN)
unnamed: GAIN.2 (S), R2.2
unnamed: GAIN_IN.P$1_TIP (TIP), R7.2
unnamed: LDR1.2 (LED+), T1.C
unnamed: R13.1, R14.1, R15.1, U2.3 (+IN)
unnamed: R13.2, TONE.2 (S)
unnamed: R14.2, TONE_IN.P$1_TIP (TIP)
unnamed: LDR2.2 (LED+), T2.C
V+: U1.8 (V+), U2.8 (V+)
V-: U1.4 (V-), U2.4 (V-)

Parts:
CP1, CP2: 10u; PANASONIC_A
D1, D2: 1N4001; SOD-123FL
JP1: HEADER2X5SHD; 2X5-SHROUDED

Connections:
+12V: CP1.+, D1.C; also elsewhere on the board
-12V: CP2.-, D2.A; also elsewhere on the board
GND: CP1.-, CP2.+, JP1.3, JP1.4, JP1.5, JP1.6, JP1.7, JP1.8; also elsewhere on the board
unnamed: D1.A, JP1.9, JP1.10
unnamed: D2.C, JP1.1, JP1.2

Board: 2 copper layers, 39.4 x 107.9 mm, 43 parts (21 on the bottom side), 33 nets.

## Commit log

2018-09-13 Added eagle files
2018-09-13 updated the readme
2018-09-13 re-arranged the traces a bit
2018-09-14 enlarged all traces and added a ground plane
2018-09-14 Revert "enlarged all traces and added a ground plane"
    This reverts commit 52d3814cfe846c563bf6933057c7568fe3819eec.
2018-09-14 Revert "Revert "enlarged all traces and added a ground plane""
    This reverts commit 74aa35135b5323656cc856a38e97fde833d2c786.
2018-09-14 Revert "Revert "Revert "enlarged all traces and added a ground plane"""
    This reverts commit ee9e4968e3ffde89da64a790338ef569f60c7a42.
2018-09-14 Tidied up a bit
    - Mittered traces
    - Enlarged the width of them
    - fixed two overlapping
2019-01-08 Added CV IN
2019-01-08 added a missing resistor
2019-01-08 grounded the jacks in
